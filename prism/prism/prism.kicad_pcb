# Repository muren400/muren_modular

File README.md:

# [muren_modular](http://muren-modular.com/ "our glorious homepage")
synthesizer modules by muren (me)
<br/>
<br/>
<br/>
<br/>
<br/>
<br/>
<br/>
<br/>
<br/>
<br/>
<br/>
<br/>
What are you doing, step-sequencer?

## KiCad design plastik/hardware/plastik.kicad_pcb

File plastik/README.md:

# plastik
plastik is a visual step sequencer based on the Arduino Platform, using the mega 2560 microcontroller

It supports arpeggios, polyphony, and drum sequences.

The pcb provided in tht hardware directory uses an arduino mega mini shield like this one:
https://www.makershop.de/plattformen/arduino/arduino-mega-pro-embed/
 
For the user interface an arduino uno compatible touchscreen shield is used. this one should work:
https://ebay.us/JfRxey

Make sure to install this library https://github.com/prenticedavid/MCUFRIEND_kbv in order to make the touch screen work.

Also this one is needed for the DAC:
https://github.com/hideakitai/MCP4728

Board: 2 copper layers, 98.0 x 99.5 mm, 38 parts (22 on the bottom side), 46 nets.

Parts:
A1: Touch_Shield
C1: CP; CP_Radial_D5.0mm_P2.50mm
J1: CV1; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J2: CV2; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J3: CV3; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J4: CV4; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J5, J6, J7, J8, J10, J11: AudioJack2_Ground_Switch; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J9: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Vertical
R1: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1, RV2, RV3, RV4: 50K; Potentiometer_Bourns_3266Y_Vertical
SW1, SW2, SW3, SW4: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm_CircularMoun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
U1: MCP4728; MSOP-10_3x3mm_P0.5mm
U2: mega_2560

Connections:
+3V3: A1.4, U2.4
+5V: A1.5, C1.1, J9.11, J9.12, R1.2, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R12.1, R13.1, R14.1, R15.1, U1.1, U2.3
GND: A1.7, C1.2, J1.S, J2.S, J3.S, J4.S, J5.S, J6.S, J7.S, J8.S, J9.3, J9.4, J9.5, J9.6, J9.7, J9.8, J10.S, J11.S, R10.1, R11.1, RV1.1, RV2.1, RV3.1, RV4.1, SW1.C, SW1.S1, SW2.C, SW2.S1, SW3.C, SW3.S1, SW4.C, SW4.S1, U1.10, U2.2, U2.23
unnamed: A1.9, U2.59
unnamed: A1.10, U2.43
unnamed: A1.11, U2.60
unnamed: A1.12, U2.44
unnamed: A1.13, U2.61
unnamed: A1.17, U2.28
unnamed: A1.18, U2.7
unnamed: A1.19, U2.29
unnamed: A1.20, U2.8
unnamed: A1.21, U2.30
unnamed: A1.22, U2.9
unnamed: A1.23, U2.31
unnamed: A1.24, U2.10
unnamed: J1.T, RV2.2
unnamed: J2.T, RV3.2
unnamed: J3.T, RV1.2
unnamed: J4.T, RV4.2
unnamed: J5.T, U2.35
unnamed: J6.T, U2.34
unnamed: J7.T, U2.33
unnamed: J8.T, U2.32
unnamed: J10.T, R10.2, U2.36
unnamed: J11.T, R11.2, U2.15
unnamed: R1.1, U1.5
unnamed: R2.2, SW4.B, U2.74
unnamed: R3.2, SW4.A, U2.73
unnamed: R4.2, SW3.B, U2.72
unnamed: R5.2, SW3.A, U2.71
unnamed: R6.2, SW2.B, U2.70
unnamed: R7.2, SW2.A, U2.69
unnamed: R8.2, SW1.B, U2.68
unnamed: R9.2, SW1.A, U2.67
unnamed: R12.2, SW3.S2, U2.41
unnamed: R13.2, SW4.S2, U2.42
unnamed: R14.2, SW2.S2, U2.40
unnamed: R15.2, SW1.S2, U2.39
unnamed: RV1.3, U1.7
unnamed: RV2.3, U1.9
unnamed: RV3.3, U1.8
unnamed: RV4.3, U1.6
unnamed: U1.2, U2.16
unnamed: U1.3, U2.37
unnamed: U1.4, U2.38

## KiCad design mixer/mixer.kicad_pcb

Parts:
J1, J2, J3, J4: IN 1; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J5: out; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J6: Conn_02x05_Odd_Even; Multicomp_MC9A12-1034_2x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7: 120k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2, RV3, RV4, RV5: 50k; Potentiometer_Alps_RK09K_Single_Vertical
U1: TL072

Connections:
+12V: J6.9, J6.10, U1.8 (V+)
-12V: J6.1, J6.2, U1.4 (V-)
GND: J1.S, J2.S, J3.S, J4.S, J5.S, J6.3, J6.4, J6.5, J6.6, J6.7, J6.8, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, U1.3 (+), U1.5 (+)
unnamed: J1.T, RV1.3
unnamed: J2.T, RV2.3
unnamed: J3.T, RV3.3
unnamed: J4.T, RV4.3
unnamed: J5.T, RV5.2
unnamed: R1.1, R2.1, R3.1, R4.1, R5.2, U1.2 (-)
unnamed: R1.2, RV1.2
unnamed: R2.2, RV2.2
unnamed: R3.2, RV3.2
unnamed: R4.2, RV4.2
unnamed: R5.1, R6.2, U1.1
unnamed: R6.1, R7.2, U1.6 (-)
unnamed: R7.1, R8.2, U1.7
unnamed: R8.1, RV5.3

Board: 2 copper layers, 29.5 x 100.0 mm, 20 parts (1 on the bottom side), 17 nets.

## KiCad design adadad/adadad.kicad_pcb

Parts:
Attack1: 1 M; Potentiometer_Alps_RK097_Single_Horizontal
C1, C2: 10 n; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3: 4.7 µ; C_Disc_D5.0mm_W2.5mm_P5.00mm
C4, C5: 22 µf; CP_Radial_D5.0mm_P2.50mm
D1, D2, D3, D5, D7: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D4: LED; LED_D5.0mm
D6: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
Decay1: 1 M; Potentiometer_Alps_RK097_Single_Horizontal
EoC_J1: AudioJack3_Ground; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
GATE_J2: AudioJack3_Ground; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
J1: Conn_02x05_Odd_Even; Multicomp_MC9A12-1034_2x05_P2.54mm_Vertical
OUT_J4: AudioJack3_Ground; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
Q1, Q2, Q3: BC547; TO-92_Inline_Wide
R2, R4, R6: 4.7 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 22 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 10 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R9: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 1 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 500k; Potentiometer_Bourns_3296W_Vertical
RV2: 100k; Potentiometer_Bourns_3296W_Vertical
U1: ICM7555; DIP-8_W7.62mm
U2: TL074; DIP-14_W7.62mm_Socket
U3: TL074

Connections:
+12V: C5.1, J1.9, J1.10, R2.1, R4.1, R6.1, RV1.1, U1.8 (VCC), U2.4 (V+), U3.4 (V+)
-12V: C4.2, J1.1, J1.2, U2.11 (V-), U3.11 (V-)
GND: C2.2, C3.1, C4.1, C5.2, D1.2 (A), D2.2 (A), EoC_J1.R, GATE_J2.R, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, OUT_J4.R, Q1.3 (E), Q2.3 (E), Q3.3 (E), RV1.3, U1.1 (GND), U3.12 (+)
unnamed: Attack1.1, D3.2 (A)
unnamed: Attack1.2, Attack1.3, R8.1
unnamed: C1.1, D2.1 (K), R5.2
unnamed: C1.2, Q2.1 (C), R4.2, U1.4 (R)
unnamed: C2.1, U1.5 (CV)
unnamed: C3.2, D3.1 (K), D5.2 (A), U1.6 (THR), U2.3 (+)
unnamed: D1.1 (K), Q1.2 (B), U2.13 (-), U2.14
unnamed: D4.1 (K), D7.2 (A), U3.14
unnamed: D4.2 (A), D7.1 (K), R10.1, U3.13 (-)
unnamed: D5.1 (K), Decay1.1
unnamed: D6.1 (K), EoC_J1.T
unnamed: D6.2 (A), RV2.3, U3.1
unnamed: Decay1.2, Decay1.3, R9.1
unnamed: GATE_J2.T, U2.12 (+)
unnamed: OUT_J4.T, U2.6 (-), U2.7
unnamed: Q1.1 (C), R2.2, R3.2
unnamed: Q2.2 (B), R3.1
unnamed: Q3.1 (C), R6.2, U1.2 (TR)
unnamed: Q3.2 (B), R5.1
unnamed: R8.2, U1.3 (Q)
unnamed: R9.2, U1.7 (DIS)
unnamed: R10.2, U3.8, U3.9 (-)
unnamed: RV1.2, U3.3 (+)
unnamed: RV2.1, U3.6 (-), U3.7
unnamed: RV2.2, U3.2 (-)
unnamed: U2.1, U2.2 (-), U2.5 (+), U3.5 (+), U3.10 (+)

Board: 2 copper layers, 30.5 x 99.5 mm, 34 parts (0 on the bottom side), 29 nets.

## KiCad design das leben der anderen/4069_v2/4069_v2.kicad_pcb

Parts:
C1, C2, C4: 220 nf; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C3: 2.2 nf; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C5, C6: 22µf; CP_Radial_D5.0mm_P2.50mm
COARSE_1: 22 k; Potentiometer_Alps_RK097_Single_Horizontal
D1, D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
FINE_1: 22 k; Potentiometer_Alps_RK097_Single_Horizontal
J1: Conn_02x05_Odd_Even; Multicomp_MC9A12-1034_2x05_P2.54mm_Vertical
PWM_1: AudioJack3_Ground; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
PWM_2: 22 k; Potentiometer_Alps_RK097_Single_Horizontal
Q1, Q2, Q4: BC550; TO-92_Inline_Wide
Q3: BC560; TO-92_Inline_Wide
R1, R10: 10 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 22 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4, R5, R7, R9, R12, R14, R15, R16, R22, R23: 100 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 68 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R17: 1 M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R11: 47 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13: 680; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18: 1.5 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R19: 33 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R20: 1 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R21: 3.3 k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV3: 1 k; Potentiometer_Bourns_3296W_Vertical
RV5, RV6, RV7: 22k; Potentiometer_Bourns_3296W_Vertical
SAW_1: AudioJack3_Ground; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
SQUARE_1: AudioJack3_Ground; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
TH1, TH2, TH3, TH4: 10 k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
U1: 4069; DIP-14_W7.62mm
V/OCT_1: AudioJack3_Ground; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal

Connections:
+12V: C6.1, J1.9, J1.10, PWM_2.1, Q1.1 (C), R6.2, R17.1, R21.1, RV5.1, RV6.1, U1.14 (VDD)
-12V: C5.2, COARSE_1.3, J1.1, J1.2, Q3.1 (C), R10.1, R19.2, R20.2, RV5.3, RV6.3, RV7.3
GNDREF: C5.1, C6.2, COARSE_1.1, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, PWM_1.R, PWM_2.3, Q2.3 (E), R7.1, R8.2, R12.2, R18.2, R22.2, RV7.1, SAW_1.R, SQUARE_1.R, U1.7 (VSS), V/OCT_1.R, V/OCT_1.S
unnamed: C1.1, R7.2, SQUARE_1.T
unnamed: C1.2, U1.6
unnamed: C2.1, Q4.2 (B), R12.1, R19.1
unnamed: C2.2, D1.1 (K), R1.2, R11.2, R13.1, U1.12
unnamed: C3.1, D1.2 (A), R13.2
unnamed: C3.2, D2.1 (K), Q2.1 (C), U1.13
unnamed: C4.1, R22.1, SAW_1.T
unnamed: C4.2, Q4.1 (C), R21.2
unnamed: COARSE_1.2, R16.2
unnamed: D2.2 (A), R2.1, U1.8
unnamed: FINE_1.1, RV6.2
unnamed: FINE_1.2, R15.2
unnamed: FINE_1.3, RV5.2
unnamed: PWM_1.T, R9.2
unnamed: PWM_2.2, R5.2
unnamed: Q1.2 (B), R8.1, R9.1
unnamed: Q1.3 (E), R4.2, R10.2
unnamed: Q2.2 (B), Q3.3 (E), R17.2
unnamed: Q3.2 (B), RV3.1, TH1.1, TH2.1, TH3.1, TH4.1
unnamed: Q4.3 (E), R20.1
unnamed: R1.1, R2.2, U1.11
unnamed: R3.1, U1.2, U1.3
unnamed: R3.2, R4.1, R5.1, R6.1, R11.1, U1.1
unnamed: R14.1, TH1.2
unnamed: R14.2, V/OCT_1.T
unnamed: R15.1, TH2.2
unnamed: R16.1, TH3.2
unnamed: R18.1, RV3.2, RV3.3
unnamed: R23.1, TH4.2
unnamed: R23.2, RV7.2
unnamed: U1.4, U1.5
unnamed: U1.9, U1.10

Board: 2 copper layers, 43.0 x 100.0 mm, 52 parts (0 on the bottom side), 35 nets.

## KiCad design das leben der anderen/lpg/lpg.kicad_pcb

Parts:
C1: 1µf; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2, C3: 22µf; CP_Radial_D5.0mm_P2.50mm
C4: 2nf; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5, C8: 220pf; C_Disc_D5.0mm_W2.5mm_P5.00mm
C6: 4.7nf; C_Disc_D5.0mm_W2.5mm_P5.00mm
C7: 1nf; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: D_Zener 3.9v; D_5W_P10.16mm_Horizontal
J3: Conn_02x05_Odd_Even; Multicomp_MC9A12-1034_2x05_P2.54mm_Vertical
JAUDIO_IN_1: Audio In; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
J_A1: jpa; PinHeader_1x02_P2.54mm_Vertical
J_AUDIO_OUT_1: Audio out; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
J_B1: jpb; PinHeader_1x02_P2.54mm_Vertical
J_CV_IN_1: CV In; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
J_DEEP1: deep; PinHeader_1x02_P2.54mm_Vertical
J_VCA1: vca1; PinHeader_1x02_P2.54mm_Vertical
J_VCA2: vca2; PinHeader_1x02_P2.54mm_Vertical
J_VCF1: vcf; PinHeader_1x02_P2.54mm_Vertical
R1, R3, R5, R10, R16: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2: 150k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R4: 470k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R6, R7: 15k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R8, R12, R14: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R9: 33k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R11: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R13: 4.7M; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R15: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
RV3, RV4: R_POT_TRIM; Potentiometer_Bourns_3296W_Vertical
RV_CV1: 100k; Potentiometer_Alps_RK097_Single_Horizontal
RV_OFFSET1: 100k; Potentiometer_Alps_RK097_Single_Horizontal
RV_RES1: 100k; Potentiometer_Alps_RK097_Single_Horizontal
U1: TL084; DIP-14_W7.62mm
U2, U3: VTL5C; PerkinElmer_VTL5C

Connections:
+12V: C3.1, J3.9, J3.10, RV_OFFSET1.1, U1.4 (V+)
-12V: C2.2, J3.1, J3.2, U1.11 (V-)
GND: C2.1, C3.2, C5.2, C7.2, D1.1 (K), J3.3, J3.4, J3.5, J3.6, J3.7, J3.8, JAUDIO_IN_1.R, J_AUDIO_OUT_1.R, J_CV_IN_1.R, J_VCA1.1, J_VCA2.1, R1.2, R3.2, R8.2, R10.2, R13.2, R16.2, RV_CV1.3, RV_OFFSET1.3
unnamed: C1.1, R3.1, U1.10 (+)
unnamed: C1.2, JAUDIO_IN_1.T, R1.1
unnamed: C4.1, R2.1, R5.1, RV3.1, RV3.2, RV4.1, U1.2 (-)
unnamed: C4.2, R4.1
unnamed: C5.1, C6.2, U2.3, U3.4
unnamed: C6.1, J_VCF1.2
unnamed: C7.1, R12.2, R13.1, U1.5 (+), U3.3
unnamed: C8.1, J_A1.1, RV_RES1.1, U1.14
unnamed: C8.2, RV_RES1.2, U1.13 (-)
unnamed: D1.2 (A), R9.1, R10.1, U2.2 (+)
unnamed: J_A1.2, J_VCF1.1
unnamed: J_AUDIO_OUT_1.T, R15.1
unnamed: J_B1.1, R14.1, R15.2, U1.7
unnamed: J_B1.2, U1.12 (+)
unnamed: J_CV_IN_1.T, RV_CV1.1
unnamed: J_DEEP1.1, R11.1, U1.1
unnamed: J_DEEP1.2, RV4.2, RV4.3
unnamed: J_VCA1.2, R7.1
unnamed: J_VCA2.2, R12.1
unnamed: R2.2, RV_OFFSET1.2
unnamed: R4.2, R5.2, RV_CV1.2
unnamed: R6.1, U1.8, U2.4
unnamed: R6.2, R7.2, U1.9 (-)
unnamed: R8.1, U1.3 (+)
unnamed: R9.2, RV3.3
unnamed: R11.2, U3.1 (-)
unnamed: R14.2, U1.6 (-)
unnamed: R16.1, RV_RES1.3
unnamed: U2.1 (-), U3.2 (+)

Board: 2 copper layers, 41.5 x 100.0 mm, 43 parts (0 on the bottom side), 32 nets.

## Commit log

2019-05-01 plastik
2019-05-01 hardware
2019-05-01 readme for plastik
2019-05-01 license
2019-05-01 cleanup
2019-06-16 plastik cv
2019-06-16 readme
2019-11-02 All kinds of stuff
2021-12-06 Added Uhr
